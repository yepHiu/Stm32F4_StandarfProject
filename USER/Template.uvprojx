# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\SYSTEM\bitband;..\HARDWARE\i2c;..\HARDWARE\led;..\HARDWARE\spi;..\HARDWARE\tim;..\HARDWARE\usart;..\SYSTEM\systick;..\SYSTEM;..\SYSTEM\DataType;..\SYSTEM\schedule;..\SYSTEM\para;..\MATH\digital_filiter;..\MATH\limits;..\MATH\median_filiter;..\MATH\pid;..\Libraries\CMSIS\Include;..\HARDWARE\pwm;..\uCOS-III\Bsp;..\uCOS-III\Config;..\uCOS-III\Core;..\uCOS-III\CPU;..\uCOS-III\Lib;..\uCOS-III\Port;..\DRONE\cam;..\DRONE\control;..\DRONE\flow;..\DRONE\interaction;..\DRONE\tof;..\SYSTEM\type_conver;..\HARDWARE\key;..\HARDWARE\beep
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c task.c task.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/bitband/: BITBAND.h
    ../SYSTEM/DataType/: DataType.h
    ../SYSTEM/para/: para.h
    ../SYSTEM/systick/: explore_systick.c
    ../SYSTEM/sys/: explore_system.c
    ../SYSTEM/type_conver/: Type_conversion.c
  group README
    ../: readme.txt
  group MATH
    ../MATH/digital_filiter/: digital_filter.c
    ../MATH/limits/: Limits.c
    ../MATH/median_filiter/: MedianFiler.c
    ../MATH/pid/: pid.c
  group HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/tim/: tim.c
    ../HARDWARE/usart/: usart1.c usart2.c usart3.c usart4.c usart5.c
    ../HARDWARE/i2c/: i2c.c
    ../HARDWARE/spi/: spi.c
    ../HARDWARE/pwm/: pwm.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/DAC/: DAC.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/beep/: beep.c
  group UCOS_BSP
    ../uCOS-III/Bsp/: bsp.c bsp.h
  group UCOS_CONFIG
    ../uCOS-III/Config/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOS_CORE
    ../uCOS-III/Core/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group UCOS_CPU
    ../uCOS-III/CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group UCOS_LIB
    ../uCOS-III/Lib/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group UCOS_PORT
    ../uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
